options:
  parameters:
    author: USRP TEAM
    generate_options: qt_gui
    id: bpsk_video
    output_language: python
    title: BPSK VIDEO TRANSFER
  states: {}

blocks:
- name: constel
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: frequency
  id: variable
  parameters:
    value: 869.525e6
  states: {}
- name: hdr
  id: variable
  parameters:
    comment: |-
      digital.header_format_default(
          digital.packet_utils.default_access_code, 0)
    value: digital.header_format_default(digital.packet_utils.default_access_code, 0)
  states: {}
- name: payload_size
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: phase_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'tabs@1: 0,2,1,1'
    label: 'Phase: Bandwidth'
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: 2*3.14/100
    widget: eng_slider
  states: {}
- name: rxgain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'tabs@1: 0,0,1,1'
    label: Receive Gain
    start: '0'
    step: '1'
    stop: '100'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1750000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: timing_loop_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'tabs@1: 0,1,1,1'
    label: 'Time: BW'
    start: '0.0'
    step: '0.01'
    stop: '0.2'
    value: '0.0628'
    widget: eng_slider
  states: {}
- name: tx_baseband_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'tabs@0: 0,0,1,1'
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.4'
  states: {}
- name: txgain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'tabs@0: 0,1,1,1'
    label: Transmit Gain
    start: '0'
    step: '1'
    stop: '80'
    value: '20'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\musta\Downloads\output.txt
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/mustafa/Documents/GNU_RADIO/TXT_FILES/input.txt
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_baseband_gain
    type: complex
  states: {}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: packet_len
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: payload_size
    type: byte
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    limit: items
    maximum: '512'
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: digital_constellation_decoder_cb_1
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constel
  states: {state: disabled}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: constel
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: digital.packet_utils.default_access_code
    tagname: packet_len
    threshold: '0'
    type: byte
  states: {state: disabled}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: len(constel.points())
    w: phase_bw
  states: {state: disabled}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_crc32_bb_1
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: packet_len
    packed: 'True'
  states: {state: disabled}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: len(constel.points())
  states: {state: disabled}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr
    len_tag_key: packet_len
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: constel.base()
    damping: '1.0'
    loop_bw: timing_loop_bw
    max_dev: '1.5'
    nfilters: '32'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {state: disabled}
- name: filter_fft_rrc_filter_0
  id: filter_fft_rrc_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: ccc
  states: {state: disabled}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '5001'
    send_eof: 'False'
    type: byte
  states: {state: disabled}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    comment: |-
      The UDP Source block listens on a specified UDP port.
      It receives UDP packets coming from an external program, another device, or a network source.
      It extracts the byte data carried inside each UDP packet.
      It feeds this data into the GNU Radio flowgraph as a byte stream.
      In ourr case, it listens on port 5000 and outputs data with byte type.
      The UDP Packet Data Size parameter defines the maximum amount of data expected from each UDP packet.
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    port: '5000'
    src_zeros: 'False'
    type: byte
  states: {}
- name: note_0
  id: note
  parameters:
    note: Receiver Side Flow
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Transmitter Side Flow
  states: {}
- name: note_2
  id: note
  parameters:
    comment: |-
      USAGE NOTES FOR FILE, IMAGE, AND VIDEO TRANSFER
      To send a TXT file or an image, use the File Source and File Sink blocks, and disable the UDP blocks.
      To send video, use the UDP blocks, and disable the File Source and File Sink blocks.
      This is the same for simulation as well.
      For the transmitter side, use only the upper side of the flowgraph, up to the USRP Sink block, and disable the bottom side of the flowgraph.
      For the receiver side, do the opposite.
      Throttle, Tag Gate, Virtual Sink (stream ID: "transmit") , and Virtual Source(stream ID: "transmit") blocks are only for simulation.
      Keep them disabled during real tests with USRP.
      When doing simulation only, enable both the transmitter and receiver sides.
      Enable Throttle, Tag Gate, and the Virtual Sink and Virtual Source blocks that have the stream ID: "transmit".
      Disable the UHD blocks during simulation.
      For video transfer, if you are on the receiver side, run the RX Python file from the Linux terminal and from its original directory, not randomly from another location.
      Then run the receiver-side flowgraph.
      If you are on the transmitter side, run the flowgraph first.
      Then run the TX Python file from the terminal and from the original directory of the TX file.
      Make sure your computer camera is open and not disabled by the camera key on the keyboard.
      The UHD block addresses on both the receiver and transmitter sides must be selected according to the SDR devices being used.
      2-channel USRP X310 address: "addr=192.168.10.2"
      1-channel USRP Ettus X310 address: "addr=192.168.10.3"
    note: USAGE NOTES
  states: {}
- name: note_2_0
  id: note
  parameters:
    comment: |-
      GENERAL OVERVIEW
      This is an SDR system that sends digital DATA / VIDEO using BPSK.
      Data -> bits -> BPSK signal -> antenna (869.525 MHz) -> bits again -> data.
      UPPER half = TRANSMITTER, LOWER half = RECEIVER.
      samp_rate = 1.75 MHz, sps = 4, meaning 4 samples per symbol, modulation = BPSK.
    note: GENERAL OVERVIEW
  states: {}
- name: note_3
  id: note
  parameters:
    comment: |-
      CONTROL KNOBS (shown in tabs when the program starts)
      tx_baseband_gain : internal amplitude of the transmitted signal
      Transmit Gain    : radio transmit power
      Receive Gain     : radio receive gain
      Time: BW         : speed of the symbol timing lock in the receiver
      Phase: Bandwidth : speed of the phase / carrier correction in the receiver, Costas loop
    note: CONTROL KNOBS
  states: {}
- name: note_4
  id: note
  parameters:
    comment: |-
      TRANSMITTER PATH (upper row, left to right)

      1. UDP/File Source: brings the bytes to be transmitted.
      2. Stream to Tagged Stream: divides the bytes into packets (payload_size = 1000).
      3. CRC32: adds an error-checking code to the packet.
      4. Protocol Formatter + Tagged Stream Mux: adds the header, access code + length,
         and combines the header + data into one packet.
      5. Constellation Modulator (BPSK): converts the bits into a signal.
      6. x tx_baseband_gain -> USRP Sink: transmits it from the antenna.
         Time Sink shows the transmitted samples.
    note: TRANSMITTER PATH (upper row, left to right)
  states: {}
- name: note_5
  id: note
  parameters:
    comment: |-
      RECEIVER PATH (bottom row, left to right)

      1. USRP Source: receives the signal from the antenna.
      2. RRC Filter: matched filter that corresponds to the shaping used in the transmitter, reducing noise.
      3. Symbol Sync: samples at the correct instant, meaning symbol timing.
      4. Costas Loop: corrects phase / frequency offset, visible on the Constellation display.
      5. Constellation Decoder + Diff Decoder: converts the signal back into bits.
      6. Correlate Access Code: finds the start of the packet. Repack Bits: collects bits into bytes.
      7. CRC32 (check): discards corrupted packets. UDP/File Sink: outputs the recovered data.
    note: RECEIVER PATH (bottom row, left to right)
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: '[1, 0, 1, 4]'
    name: '"Constellation"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: '[0, 0, 1, 2]'
    label1: Real
    label2: Imag
    name: '"Transmitted Samples"'
    size: '1024'
    srate: samp_rate
    style2: '3'
    tr_delay: '0.0'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: '[0, 2, 1, 2]'
    label1: Real
    label2: Imag
    name: Recovered Symbols
    size: '256'
    srate: samp_rate/sps
    style2: '3'
    tr_delay: '0.0'
    tr_level: '0.01'
    type: complex
    update_time: '0.1'
    ymax: '1.5'
    ymin: '-1.5'
  states: {state: disabled}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,0,1,4
    label0: TX
    label1: RX
    num_tabs: '2'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: frequency
    dev_addr: '"addr=192.168.10.2"'
    gain0: txgain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: frequency
    dev_addr: '"addr=192.168.10.2"'
    gain0: rxgain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: packet
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: transmit
  states: {state: disabled}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: recovery
  states: {state: disabled}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: rx_payload
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: packet
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: transmit
  states: {state: disabled}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: recovery
  states: {state: disabled}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: rx_payload
  states: {state: disabled}

connections:
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_tag_gate_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_repack_bits_bb_1, '0', digital_crc32_bb_1, '0']
- [blocks_stream_to_tagged_stream_0_0_0, '0', digital_crc32_bb_0, '0']
- [blocks_tag_gate_0, '0', virtual_sink_1, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0, '0']
- [digital_constellation_decoder_cb_1, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_time_sink_x_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', virtual_sink_4, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_time_sink_x_1_0, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_3, '0']
- [digital_crc32_bb_0, '0', blocks_tagged_stream_mux_0, '1']
- [digital_crc32_bb_0, '0', digital_protocol_formatter_bb_0, '0']
- [digital_crc32_bb_1, '0', blocks_file_sink_0_0, '0']
- [digital_crc32_bb_1, '0', network_udp_sink_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [filter_fft_rrc_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [network_udp_source_0, '0', blocks_stream_to_tagged_stream_0_0_0, '0']
- [uhd_usrp_source_0, '0', filter_fft_rrc_filter_0, '0']
- [virtual_source_0, '0', digital_constellation_modulator_0, '0']
- [virtual_source_1, '0', filter_fft_rrc_filter_0, '0']
- [virtual_source_2, '0', digital_constellation_decoder_cb_1, '0']
- [virtual_source_4, '0', blocks_repack_bits_bb_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
