options:
  parameters:
    generate_options: qt_gui
    id: analog_data_transfer
    output_language: python
    title: Walkie Talkie
  states: {}

blocks:
- name: bw
  id: variable_qtgui_range
  parameters:
    label: ch0_bandwidth
    start: '0'
    step: 1e3
    stop: 200e3
    value: 100e3
  states: {}
- name: drc
  id: variable_qtgui_range
  parameters:
    label: direction
    start: '0'
    step: '1'
    stop: '1'
    value: '1'
  states: {}
- name: freq_dev
  id: variable_qtgui_range
  parameters:
    label: NBFM max frequency deviation
    start: '250'
    step: '2'
    stop: '2000'
    value: '500'
  states: {}
- name: mic_gain
  id: variable_qtgui_range
  parameters:
    label: mic_gain
    start: '0.3'
    step: '0.05'
    stop: '2.0'
    value: '0.5'
  states: {}
- name: ptt
  id: variable_qtgui_push_button
  parameters:
    label: ptt
    pressed: '1'
    released: '0'
    type: int
    value: '1'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: rx_gain
    start: '-20'
    step: '2'
    stop: '50'
    value: '40'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: tx_gain
    start: '0'
    step: '1'
    stop: '80'
    value: '40'
  states: {}
- name: volume_control
  id: variable_qtgui_range
  parameters:
    label: volume_control
    start: '0.5'
    step: '0.1'
    stop: '5.0'
    value: '1.8'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: freq_dev
    quad_rate: '192000'
    tau: '75e-6'
  states: {}
- name: analog_nbfm_rx_0_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: freq_dev
    quad_rate: '192000'
    tau: '75e-6'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: '48000'
    fh: '-1.0'
    max_dev: freq_dev
    quad_rate: '192000'
    tau: '75e-6'
  states: {}
- name: analog_nbfm_tx_0_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: '48000'
    fh: '-1.0'
    max_dev: freq_dev
    quad_rate: '192000'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '6000'
    low_cutoff_freq: '300'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '6000'
    low_cutoff_freq: '300'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: mic gain
    const: mic_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: volume control
    const: volume_control
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    comment: push to talk
    const: ptt
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: push to talk
    const: ptt
    type: float
  states: {}
- name: blocks_multiply_const_vxx_3
  id: blocks_multiply_const_vxx
  parameters:
    comment: channel 0
    const: drc
    type: float
  states: {}
- name: blocks_multiply_const_vxx_3_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: channel 1
    const: 1-drc
    type: float
  states: {}
- name: blocks_multiply_const_vxx_3_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: channel 1
    const: 1-drc
    type: float
  states: {}
- name: blocks_multiply_const_vxx_3_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: channel 0
    const: drc
    type: float
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: '300'
    decim: '1'
    gain: '1'
    samp_rate: 48e3
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 10e3
    decim: '1'
    gain: '1'
    samp_rate: 1e6
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 10e3
    decim: '1'
    gain: '1'
    samp_rate: 1e6
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '6000'
    decim: '1'
    gain: '1'
    samp_rate: 48e3
    type: fir_filter_fff
    width: '300'
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      GENERAL OVERVIEW - WHAT IS THIS?
      This is a WALKIE-TALKIE. The radio is not just a box, it is SOFTWARE.
      This is called SDR (Software Defined Radio): the antenna box (USRP)
      only receives and transmits signals through the air, while the "brain"
      that processes the audio is this flowgraph.
      Frequency: 462.5625 MHz (a real walkie-talkie channel).
      UPPER half = TALKING (microphone -> radio wave)
      LOWER half = LISTENING (radio wave -> speaker)
      The signal always flows from LEFT to RIGHT.
    note: GENERAL OVERVIEW - WHAT IS THIS?
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Transmitter Side Flow
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: Receiver Side Flow
  states: {}
- name: note_1
  id: note
  parameters:
    comment: |-
      CONTROL KNOBS (sliders appear on the screen when the program starts)
      mic_gain        : microphone input volume level
      volume_control  : speaker output volume level
      tx_gain         : radio transmit power
      rx_gain         : radio receive sensitivity
      ptt             : push-to-talk. 1=transmits, 0=mutes
      ch0_bandwidth   : bandwidth of the radio’s hardware filter
      direction (drc) : switch that selects which channel is used for
                        speaking and which channel is used for listening (0 / 1)
      freq_dev        : FM signal deviation, meaning how much the frequency can vary
    note: CONTROL KNOBS
  states: {}
- name: note_2
  id: note
  parameters:
    comment: |-
      Audio Source: receives audio from the microphone
      48 kHz means 48,000 samples per second.
      High Pass Filter (300 Hz): removes low-frequency rumble and deep background noise.
      Low Pass Filter (6 kHz): removes high-frequency hiss and sharp noise.
      Together, these filters leave mainly the human voice, similar to telephone-quality speech.
      Mic Gain (× mic_gain): adjusts the microphone volume level.
      Push to Talk (× ptt):
      If ptt = 1, the audio passes through.
      If ptt = 0, the audio is multiplied by zero and becomes silent.
      This is the push-to-talk switch.
    note: VOICE PATH — 1) CLEAN THE AUDIO
  states: {}
- name: note_3
  id: note
  parameters:
    comment: |-
      WHY ARE THERE TWO BRANCHES? (channel 0 / channel 1)
      The radio has 2 channels. "direction" (drc) selects which one is active:
      one branch  x drc ,  the other branch  x (1 - drc)
      -> only ONE of them is active at the same time.
      This allows two radios to communicate without overlapping: while one radio
      transmits from channel 0, the other listens to it from channel 1.
      When the switch is changed, the roles are reversed.
    note: WHY ARE THERE TWO BRANCHES?
  states: {}
- name: note_4
  id: note
  parameters:
    comment: |-
      WHAT IS NBFM?
      FM (Frequency Modulation) is used to carry audio through the air

      * similar to FM radio, but NARROWBAND, which is walkie-talkie style.
        NBFM Transmit : converts audio into an FM signal while transmitting
        NBFM Receive  : converts the FM signal back into audio while receiving
        "Audio 48k / Quadrature 192k": internally, the audio side is 48 kHz
        and the radio signal side is 192 kHz.
    note: WHAT IS NBFM?
  states: {}
- name: note_5
  id: note
  parameters:
    comment: |-
      RATIONAL RESAMPLER = RATE CONVERTER (like a gearbox)
      Each part works at a different rate: audio is 48k, the FM side is 192k, and the radio (USRP) is 1 MHz.
      This block matches these rates to each other:
      While transmitting : 192,000 x (125/24) = 1,000,000  (goes UP to the radio rate)
      While receiving    : 1,000,000 x (24/125) = 192,000  (goes DOWN to the FM rate)
      Interpolation = multiply / speed up,  Decimation = divide / slow down.
    note: RATIONAL RESAMPLER = RATE CONVERTER (like a gearbox)
  states: {}
- name: note_6
  id: note
  parameters:
    comment: |-
      LISTENING PATH (bottom row, left to right)

      1. USRP Source: receives the raw radio signal from the antenna (1 MHz).
      2. Low Pass + Resampler + NBFM Receive: filters it and converts it back into audio.
      3. Band Pass Filter (300-6000 Hz): again, passes only the speech range.
      4. direction multiplier -> Add: combines the ACTIVE one of the 2 channels into a single audio signal.
      5. x ptt: cuts the audio so you do not hear your own transmission while talking.
      6. x volume_control -> Audio Sink: sends the audio to the speaker (48 kHz).
    note: LISTENING PATH (bottom row, left to right)
  states: {}
- name: note_7
  id: note
  parameters:
    comment: |-
      DISPLAYS (bottom right) - visual only, they do not affect the audio
      QT GUI Waterfall Sink : shows frequencies over time with colors, like a waterfall.
      QT GUI Frequency Sink : shows the spectrum of the current signal, meaning the frequency graph.
      Both are connected to the receive output and allow you to SEE the signal.
    note: DISPLAY
  states: {}
- name: note_8
  id: note
  parameters:
    comment: |-
      When using one USRP, one channel can transmit while the other channel can receive.
      If you change the direction value, the roles are swapped:
      the previously receiving channel starts transmitting, and the previously transmitting channel starts receiving.
      If you want to listen from another USRP, disable the upper part and activate the lower part.
      Be careful with the addresses. Each USRP has a different address value, and you must set it manually.
      If you are only on the receiver side, changing transmitter-side parameters will not affect anything because the transmitter part, which is the upper part of the flowgraph, is disabled.
    note: General Usage
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '50000'
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '50000'
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '125'
    interp: '24'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '125'
    interp: '24'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '24'
    interp: '125'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '24'
    interp: '125'
    type: ccc
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    bw0: bw
    bw1: bw
    center_freq0: 462.5625e6
    center_freq1: 462.5625e6
    dev_addr: '"addr=192.168.10.2"'
    gain0: tx_gain
    gain1: tx_gain
    nchan: '2'
    samp_rate: 1e6
    sd_spec0: '"A:0 B:0"'
    stream_chans: '[0,1]'
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    bw0: bw
    bw1: bw
    center_freq0: 462.5625e6
    center_freq1: 462.5625e6
    dev_addr: '"addr=192.168.10.2"'
    gain0: rx_gain
    gain1: rx_gain
    nchan: '2'
    samp_rate: 1e6
    sd_spec0: '"A:0 B:0"'
    stream_chans: '[0,1]'
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_nbfm_rx_0, '0', band_pass_filter_0, '0']
- [analog_nbfm_rx_0_0, '0', band_pass_filter_0_0, '0']
- [analog_nbfm_tx_0, '0', rational_resampler_xxx_0_1, '0']
- [analog_nbfm_tx_0_0, '0', rational_resampler_xxx_0_1_0, '0']
- [audio_source_0, '0', high_pass_filter_0, '0']
- [band_pass_filter_0, '0', blocks_multiply_const_vxx_3_0_0, '0']
- [band_pass_filter_0_0, '0', blocks_multiply_const_vxx_3_1, '0']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_2_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_multiply_const_vxx_1, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_multiply_const_vxx_2, '0', blocks_multiply_const_vxx_3, '0']
- [blocks_multiply_const_vxx_2, '0', blocks_multiply_const_vxx_3_0, '0']
- [blocks_multiply_const_vxx_2_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_const_vxx_3, '0', analog_nbfm_tx_0, '0']
- [blocks_multiply_const_vxx_3_0, '0', analog_nbfm_tx_0_0, '0']
- [blocks_multiply_const_vxx_3_0_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_3_1, '0', blocks_add_xx_0, '1']
- [high_pass_filter_0, '0', low_pass_filter_1, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0_0, '0']
- [low_pass_filter_0_0, '0', rational_resampler_xxx_0_0_0, '0']
- [low_pass_filter_1, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0_0, '0', analog_nbfm_rx_0, '0']
- [rational_resampler_xxx_0_0_0, '0', analog_nbfm_rx_0_0, '0']
- [rational_resampler_xxx_0_1, '0', uhd_usrp_sink_0, '0']
- [rational_resampler_xxx_0_1_0, '0', uhd_usrp_sink_0, '1']
- [uhd_usrp_sink_0, async_msgs, uhd_usrp_sink_0, command]
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']
- [uhd_usrp_source_0, '1', low_pass_filter_0_0, '0']
- [uhd_usrp_source_0, async_msgs, uhd_usrp_source_0, command]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
