options:
  parameters:
    author: USRP TEAM
    generate_options: qt_gui
    id: qpsk_txt_transfer
    output_language: python
    title: QPSK DIGITAL DATA TRANSFER
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: arity
  id: variable
  parameters:
    value: '4'
  states: {}
- name: eq_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'tabs@1: 0,3,1,1'
    label: 'Equalizer: rate'
    start: '0.0'
    step: '0.001'
    stop: '0.1'
    value: '0.01'
    widget: eng_slider
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 920e6
  states: {}
- name: frequency
  id: variable
  parameters:
    value: 869.525e6
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 1)
  states: {}
- name: length_tag_key
  id: variable
  parameters:
    value: '''packet_len'''
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '90'
  states: {}
- name: phase_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'tabs@1: 0,2,1,1'
    label: 'Phase: Bandwidth'
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: '0.150'
    widget: eng_slider
  states: {}
- name: postamble_size
  id: variable
  parameters:
    value: '8'
  states: {}
- name: preamble_size
  id: variable
  parameters:
    value: '250'
  states: {}
- name: qpsk
  id: variable_constellation
  parameters:
    npwr: '1'
    precision: '8'
    type: qpsk
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: rs_ratio
  id: variable
  parameters:
    value: '1.040'
  states: {}
- name: rxgain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'tabs@1: 0,0,1,1'
    label: Receive Gain
    start: '0'
    step: '1'
    stop: '100'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0, 0.25-0.25j, 0.50 + 0.10j, -0.3 + 0.2j]'
  states: {}
- name: timing_loop_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'tabs@1: 0,1,1,1'
    label: 'Time: BW'
    start: '0.0'
    step: '0.01'
    stop: '0.2'
    value: '0.0628'
    widget: eng_slider
  states: {}
- name: tx_baseband_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'tabs@0: 0,0,1,1'
    label: TX Baseband Gain
    start: '0'
    step: '0.01'
    stop: '3'
    value: '0.4'
  states: {}
- name: txgain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'tabs@0: 0,1,1,1'
    label: Transmit Gain
    start: '0'
    step: '1'
    stop: '80'
    value: '12'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0003'
    type: cma
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.02'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    comment: This block saves the received byte data to a file. In this setup, the output is written to output.txt in the Downloads folder. The input type is byte, so the block stores the recovered data as raw byte data. Since unbuffered mode is enabled, the data is written to the file immediately. The overwrite option means the old file content is replaced each time the flowgraph starts.
    file: C:\Users\musta\Downloads\output.txt
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: Make sure to specify the correct file path of the file that will be transmitted.
    file: /home/mustafa/Documents/GNU_RADIO/TXT_FILES/input.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_baseband_gain
    type: complex
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {state: disabled}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    comment: This block creates packets with a specified number of bytes. The packet size is defined in the Packet Length section, and the block attaches a length tag key to each packet.
    len_tag_key: length_tag_key
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: preamble_size
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: postamble_size
    type: byte
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: length_tag_key
    ninputs: '4'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    comment: |-
      Yellow color means the block is bypassed.
      Think of it as if there is only a wire in that place.
      The Throttle block is used only in simulation to limit the processing speed.
    samples_per_second: samp_rate
    type: byte
  states: {state: bypassed}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: |-
      Preamble
      A preamble is a known bit sequence added at the beginning of a packet so that the receiver can detect the packet start and establish proper synchronization and bit timing.
    repeat: 'True'
    type: byte
    vector: '[0xc0, 0xaf]'
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    comment: |-
      Postamble
      A postamble is a known bit sequence added at the end of a packet to indicate that the packet has finished and to help the receiver cleanly detect the end of the transmission.
    repeat: 'True'
    type: byte
    vector: '[0xc0, 0xaf]'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: This block receives the phase corrected complex IQ signal from the Costas Loop. After the Costas Loop reduces carrier phase and small frequency errors, the Constellation Decoder decides which QPSK constellation point each received symbol is closest to. It then converts these QPSK symbols back into digital symbol or bit information. In this setup, the decoder uses the QPSK constellation object, so the incoming signal is expected to contain QPSK symbols. The output is no longer a complex IQ signal. It is decoded digital data that can be used by the following packet and data recovery blocks.
    constellation: qpsk
  states: {state: disabled}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    comment: Constellation Modulator converts input bits into complex IQ symbols according to the selected modulation scheme.
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_key
    comment: This block searches the received byte stream for the access code. When the access code is detected, it marks the start of the packet and adds a packet_len tag. This helps the following blocks understand where the packet begins and how it should be processed. The threshold value allows a small number of bit errors during access code detection.
    tagname: packet_len
    threshold: '1'
    type: byte
  states: {state: disabled}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    comment: This block is used for carrier recovery. The received signal may have phase and frequency errors because the transmitter and receiver are not perfectly synchronized. The Costas Loop tracks and corrects these phase errors so the constellation points rotate back to their correct positions. This makes the received symbols easier to detect and decode. In this setup, the loop bandwidth controls how fast the block reacts to phase changes. The order value should match the modulation type, such as 2 for BPSK or 4 for QPSK. This block mainly corrects carrier phase and small frequency offsets before symbol decisions are made.
    order: arity
    w: phase_bw
  states: {state: disabled}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    comment: This blocks adds CRC bytes to each packet so that the receiver can check whether the packet is corrupted or not.
    lengthtagname: length_tag_key
    packed: 'True'
  states: {}
- name: digital_crc32_bb_0_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    comment: This block checks the CRC32 value of each received packet. It uses the packet_len tag to know the packet boundaries. If the calculated CRC matches the received CRC, the packet is accepted. If the CRC does not match, the packet is considered corrupted and can be rejected. This is used to detect broken or damaged packets at the receiver side.
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {state: disabled}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: This block receives the decoded QPSK symbols after the Constellation Decoder. Since differential encoding was used at the transmitter side, this block performs differential decoding at the receiver side. It recovers the original symbol information by looking at the change between consecutive symbols instead of only their absolute values. The modulus is set to 4 because QPSK has 4 possible constellation states. This helps solve phase ambiguity problems that may occur during carrier recovery. After this block, the signal is closer to the original transmitted digital data and can be passed to the following packet recovery blocks.
    modulus: '4'
  states: {state: disabled}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    comment: This block is used to reduce the distortion caused by the communication channel. The received signal may be affected by multipath, reflections, noise, or channel imperfections. The Linear Equalizer tries to correct these effects by filtering the signal before symbol decisions are made. It uses multiple filter taps to compensate for channel distortion. In this setup, the equalizer works with 2 samples per symbol and uses an adaptive algorithm to update its filter coefficients. The corr_est tag indicates where the training or correction process should start. After equalization, the output signal becomes cleaner and easier for the demodulation blocks to decode correctly.
    num_taps: '15'
    sps: '2'
  states: {state: disabled}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    comment: This block maps the decoded symbol values to the expected output values. Since the map is [0, 1, 2, 3], the symbols stay in the same order and no real remapping is done.
    map: '[0,1,2,3]'
  states: {state: disabled}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    comment: This block takes the complex IQ signal from the USRP Source and performs timing synchronization. Its main job is to find the correct time to read each received symbol. The received signal may not be perfectly aligned because the transmitter and receiver clocks are not exactly the same. This block corrects small timing differences and helps the receiver sample each symbol at the right moment. It also uses RRC filter taps to make the signal cleaner before demodulation. The output is still a complex IQ signal, but it is better synchronized and easier for the next demodulation blocks to decode. This block is mainly used for symbol timing synchronization, not for frequency correction.
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: timing_loop_bw
    max_dev: '1.5'
    osps: '2'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {state: disabled}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    comment: This block create the packet header, which contains information such as the access code and payload length.
    format: hdr_format
    len_tag_key: length_tag_key
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    comment: This block sends the received byte data from GNU Radio to an external program using UDP. In this setup, it sends the data to 127.0.0.1 on port 5001, which means the data is sent to another application running on the same computer. The UDP Packet Data Size defines the maximum size of each UDP packet. This block is usually used at the receiver side to forward recovered data, such as video or file data, to another program for display or saving.
    header: '0'
    payloadsize: '1472'
    port: '5001'
    send_eof: 'False'
    type: byte
  states: {state: disabled}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    comment: |-
      The UDP Source block listens on a specified UDP port.
      It receives UDP packets coming from an external program, another device, or a network source.
      It extracts the byte data carried inside each UDP packet.
      It feeds this data into the GNU Radio flowgraph as a byte stream.
      In ourr case, it listens on port 5000 and outputs data with byte type.
      The UDP Packet Data Size parameter defines the maximum amount of data expected from each UDP packet.
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    port: '5000'
    src_zeros: 'False'
    type: byte
  states: {state: disabled}
- name: note_0
  id: note
  parameters:
    comment: |-
      BIG PICTURE - WHAT IS THIS?
      This is a radio that sends a DIGITAL FILE (e.g. a text file) over the air
      using QPSK. The radio is software (SDR); the USRP box is just the antenna
      front-end. Carrier frequency: 869.525 MHz.

      Flow:  file bytes -> packet -> QPSK signal -> antenna
             -> antenna -> recover signal -> bytes -> saved file
      TOP = TRANSMITTER (send),   BOTTOM = RECEIVER (recover).
      QPSK = 2 bits per symbol.  sps=4 (4 samples per symbol).  samp_rate=1 MHz.
    note: BIG PICTURE - WHAT IS THIS?
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Receiver Side Flow
  states: {state: disabled}
- name: note_0_0_0
  id: note
  parameters:
    note: Transmitter Side Flow
  states: {}
- name: note_1
  id: note
  parameters:
    comment: |-
      THE SLIDERS (appear as tabs when the program runs)
      TX Baseband Gain : digital amplitude of the signal before the radio
      Transmit Gain    : the radio's transmit power
      Receive Gain     : the radio's receive amplification
      Time: BW         : speed of the symbol-timing lock (receiver)
      Phase: Bandwidth : speed of carrier phase/frequency correction (receiver)
      Equalizer: rate  : how fast the equalizer adapts to channel distortion
    note: THE SLIDERS
  states: {}
- name: note_2
  id: note
  parameters:
    comment: |-
      TRANSMITTER - STEP 1: BUILD THE PACKET (data -> bytes -> packet)
      1. File / UDP source: brings in the bytes to send.
      2. Stream to Tagged Stream: cuts the bytes into packets (packet_len=90)
         and tags each packet's length.
      3. CRC32 (add): appends an error-check code so the receiver can tell
         whether a packet arrived corrupted.
      4. Protocol Formatter: builds a HEADER (access code + length) in front.
      5. Preamble & Postamble: known byte patterns added before/after, so the
         receiver can find where each packet starts and ends.
      6. Tagged Stream Mux: glues PREAMBLE + HEADER + DATA + POSTAMBLE into
         one complete packet.
    note: 'TRANSMITTER - STEP 1: BUILD THE PACKET'
  states: {}
- name: note_2_0
  id: note
  parameters:
    comment: |-
      USAGE NOTES FOR FILE, IMAGE, AND VIDEO TRANSFER
      To send a TXT file or an image, use the File Source and File Sink blocks, and disable the UDP blocks.
      Make sure the correct file path is specified in the File Source block for the file that will be transmitted.
      Also specify the correct output path in the File Sink block on the receiver side.
      To send video, use the UDP blocks, and disable the File Source and File Sink blocks.
      This is the same for simulation as well.
      For the transmitter side, use only the upper side of the flowgraph, up to the USRP Sink block, and disable the bottom side of the flowgraph.
      For the receiver side, do the opposite.
      Throttle, Prob Rate, Message Debug, Noise Source, Virtual Sink (stream ID: "transmit"), and Virtual Source (stream ID: "transmit") blocks are only for simulation.
      Keep them disabled during real tests with USRP.
      When doing simulation only, enable both the transmitter and receiver sides.
      Enable Throttle, Prob Rate, Message Debug, Noise Source, and the Virtual Sink and Virtual Source blocks that have the stream ID: "transmit".
      Disable the UHD blocks during simulation.
      For video transfer, if you are on the receiver side, run the RX Python file from the Linux terminal and from its original directory, not from an arbitrary location.
      Then run the receiver-side flowgraph.
      If you are on the transmitter side, run the flowgraph first.
      Then run the TX Python file from the terminal and from the original directory of the TX file.
      Make sure your computer camera is open and not disabled by the camera key on the keyboard.
      The UHD block addresses on both the receiver and transmitter sides must be selected according to the SDR devices being used.
      2-channel USRP X310 address: "addr=192.168.10.2"
      1-channel USRP Ettus X310 address: "addr=192.168.10.3"
      If you see 4 points on the constellation diagram, it means the signal is being received.
      However, if no data is flowing in the "data to write rx" section, the constellation diagram is not being interpreted correctly.
      This usually means there is a phase shift.
      To fix this, reduce the Phase: Bandwidth parameter using the slider.
      Then adjust it until the constellation diagram reaches the correct position.
      When the correct position is found, the bytes will pass through the CRC32 check and will be written to the output file.
      If the 2 USRP devices are too close to each other, do not use too much transmit power.
    note: USAGE NOTES
  states: {}
- name: note_3
  id: note
  parameters:
    comment: |-
      TRANSMITTER - STEP 2: TURN BITS INTO A SIGNAL
      1. Constellation Modulator (QPSK): maps the bits onto QPSK symbols and
         shapes them into a smooth waveform (RRC, excess_bw=0.35).
      2. Tag Gate: removes stream tags so they don't disturb the hardware.
      3. x TX Baseband Gain: sets the signal's amplitude.
      4. USRP Sink: sends it out through the antenna.
      The Time Sink shows the transmitted samples on screen.
    note: 'TRANSMITTER - STEP 2: TURN BITS INTO A SIGNAL'
  states: {}
- name: note_4
  id: note
  parameters:
    comment: |-
      SIMULATION CHANNEL (the "sim" part - usually optional/disabled)
      Noise Source + Add: takes the transmitted signal and adds random noise
      to FAKE a real radio channel. This lets you test the receiver WITHOUT
      real hardware: the noisy signal is fed straight back into the receiver.
      More noise = harder for the receiver = more errors.
    note: SIMULATION CHANNEL
  states: {}
- name: note_5
  id: note
  parameters:
    comment: |-
      RECEIVER - RECOVER THE DATA (antenna -> bytes)
      1. USRP Source: receives the RF signal.
      2. PFB Clock Sync: matched filter + finds the right instant to sample
         each symbol (symbol timing).
      3. Linear Equalizer (CMA): undoes the distortion the channel added.
      4. Costas Loop: corrects carrier phase/frequency offset.
         (The Constellation sink shows 4 clean dots when this works.)
      5. Constellation Decoder + Diff Decoder + Map: symbols back into bits.
      6. Correlate Access Code: locates the packet start using the access code.
      7. Repack Bits -> CRC32 (check): rebuild bytes, drop corrupted packets.
      8. File / UDP Sink: writes the recovered data out.
    note: RECEIVER - RECOVER THE DATA
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: '[2, 3, 1, 1]'
    name: '"Constellation"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: 1,0,1,3
    grid: 'True'
    gui_hint: '[0, 0, 1, 4]'
    label1: ''
    label2: ''
    name: Transmitted Data
    size: '1024'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.1'
    tr_tag: '"packet_len"'
    type: complex
    ymax: '1.1'
    ymin: '-0.1'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: '[2, 2, 1, 1]'
    label1: Rx Bits
    name: '"Data to Write RX"'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: '[2, 0, 1, 2]'
    label1: Symbols
    name: '"Decoded Signals RX"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '4'
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: '[1, 0, 1, 4]'
    name: '"Received Complex Signal"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 3,0,1,4
    label0: TX
    label1: RX
    num_tabs: '2'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: frequency
    comment: UHD USRP Sink block takes the complex IQ signal from the GNU Radio flowgraph and sends it to the USRP hardware for RF transmission.
    dev_addr: '"addr=192.168.10.2"'
    gain0: txgain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: frequency
    comment: The UHD USRP Source block receives RF signals from the USRP hardware, converts them into complex IQ samples, and feeds them into the GNU Radio flowgraph for further processing and demodulation.
    dev_addr: '"addr=192.168.10.2"'
    gain0: rxgain
    samp_rate: samp_rate
    sd_spec0: '"B:0"'
    sync: sync
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: transmit
  states: {state: disabled}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: t1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: t1
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: transmit
  states: {state: disabled}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_probe_rate_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_add_xx_0, '0', virtual_sink_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_repack_bits_bb_0, '0', blocks_char_to_float_0_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_crc32_bb_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_crc32_bb_0, '0']
- [blocks_stream_to_tagged_stream_0_0_0_0, '0', blocks_tagged_stream_mux_0, '0']
- [blocks_stream_to_tagged_stream_0_0_0_0_0, '0', blocks_tagged_stream_mux_0, '3']
- [blocks_tag_gate_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0_0, '0']
- [blocks_throttle2_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_to_tagged_stream_0_0_0_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_stream_to_tagged_stream_0_0_0_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_char_to_float_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0, '0', blocks_tag_gate_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_crc32_bb_0, '0', blocks_tagged_stream_mux_0, '2']
- [digital_crc32_bb_0, '0', digital_protocol_formatter_bb_0, '0']
- [digital_crc32_bb_0_0, '0', blocks_file_sink_0_0, '0']
- [digital_crc32_bb_0_0, '0', network_udp_sink_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_linear_equalizer_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '1']
- [network_udp_source_0, '0', blocks_throttle2_0, '0']
- [uhd_usrp_source_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_1, '0']
- [virtual_source_0, '0', digital_constellation_modulator_0, '0']
- [virtual_source_1, '0', digital_pfb_clock_sync_xxx_0, '0']
- [virtual_source_1, '0', qtgui_time_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
